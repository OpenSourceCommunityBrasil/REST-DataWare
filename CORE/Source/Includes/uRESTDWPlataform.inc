{$I ..\..\Source\Includes\uRESTDW.inc}

{$IF Defined(FPC)}
 {$IFDEF CPU32}
  {$DEFINE CPU32}
 {$ENDIF CPU32}
 {$IFDEF CPU64}
  {$DEFINE CPU64}
 {$ENDIF CPU64}
{$ELSE}
 {$IF Defined(CPUX32)}
  {$DEFINE CPU32}
 {$ELSEIF CPUX64}
  {$DEFINE CPU64}
 {$ELSE}
  {$DEFINE CPU32}
 {$IFEND}
{$IFEND}

{$IFDEF MSWINDOWS}
 {$DEFINE RESTDWWINDOWS}
{$ENDIF}
{$IFNDEF FPC}
 {$if CompilerVersion < 24}//Delphi under XE3
  //Geral
  {$DEFINE RESTDWINDY}
  {.$DEFINE RESTDWCLIENTDATASET}
  {.$DEFINE RESTDWUNIDACMEM}
  {$DEFINE RESTDWMEMTABLE}
 {$ELSE}// > Xe3
  //Geral
  {$DEFINE RESTDWFDMEMTABLE} //FireDAC somente Xe3 pra cima
  {.$DEFINE RESTDWMEMTABLE}
  {.$DEFINE RESTDWUNIDACMEM}
  {$IF Defined(HAS_FMX)}
   {$IF Defined(HAS_UTF8)}
    {$DEFINE RESTDWFMX}
    {.$DEFINE RESTDWAndroidService}
   {$IFEND}
  {$ELSE}
   {$DEFINE RESTDWDESKTOP}
  {$IFEND}
 {$IFEND}
{$ELSE} //Lazarus
 {.$DEFINE RESTDWFHTTP}
 {.$DEFINE RESTDWLAMW} //For LAMW
 {.$DEFINE RESTDWLAZDRIVER}
 {.$DEFINE RESTDWUNIDACMEM}
 {$DEFINE RESTDWMEMTABLE}
{$ENDIF}
{.$DEFINE RESTDWSYNOPSE}